FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fragment.cfg"
SRCREV_FORMAT = "meta.machine"
