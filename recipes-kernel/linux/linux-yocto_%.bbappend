SRCREV_FORMAT = "meta.machine"
